# IAR project Backup of KSDK2_MKV58F24.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV58F1M0xxx24 NXP MKV58F1M0xxx24
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MKV58F1M0VLQ24_cm7; FSL_RTOS_BM; CPU_MKV58F1M0VLQ24; SDK_CORE_ID_CORE0; SDK_OS_BAREMETAL
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../app/; ../app/inc/; ../app/src/; ../board/; ../board/inc/; ../board/src/; ../drivers/inc/; ../drivers/src/; ../Library/; ../Library/CMSIS/Include/; ../Library/MKV58F24/; ../Library/MKV58F24/drivers/; ../Library/MKV58F24/startup/; ../Library/MKV58F24/utilities/; ../middleware/dma_manager_2.1.0/; ../middleware/sdmmc_2.1.2/inc/; ../middleware/sdmmc_2.1.2/src/; ../middleware/fatfs_0.12b/src/; ../middleware/fatfs_0.12b/src/fsl_sd_disk/; ../middleware/fatfs_0.12b/src/fsl_mmc_disk/; ../middleware/Terminal_0.01a/inc/; ../middleware/Terminal_0.01a/src/; ../../..; ../
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: CMSIS; board; drivers; startup; utilities
  OBJCOPY.OOCOutputFile: KSDK2_MKV58F24.srec
  ILINK.IlinkOutputFile: cproject_templates.out
  ILINK.IlinkIcfFile: KSDK2_MKV58F24.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; CPU_MKV58F1M0VLQ24_cm7; FSL_RTOS_BM; CPU_MKV58F1M0VLQ24; SDK_CORE_ID_CORE0; SDK_OS_BAREMETAL
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MKV58F1M0xxx24_flash.icf
  group (top)
    ./: MKV58F1M0xxx24_flash.icf
  group app
    ../app/: include.h main.c
  group app/inc
    ../app/inc/: PART_ASCII.h PART_CarControl.h PART_CarSystem.h PART_I2C&&SCCB.h PART_Keys.h PART_Menu.h PART_Motor.h PART_Parameter.h PART_UpperCOM.h RUS_GeneratePath.h RUS_ImageCorrection.h RUS_RoadDiscern.h
  group app/src
    ../app/src/: PART_ASCII.c PART_CarConrtol.c PART_CarSystem.c PART_I2C&&SCCB.c PART_Keys.c PART_Menu.c PART_Motor.c PART_Parameter.c PART_UpperCOM.c RUS_GeneratePath.c RUS_ImageCorrection.c RUS_RoadDiscern.c
  group board
    ../board/: BOARD_Initialize.c
  group board/inc
    ../board/inc/: board.h clock_config.h pin_mux.h RTE_Device.h
  group board/src
    ../board/src/: board.c clock_config.c pin_mux.c
  group drivers/inc
    ../drivers/inc/: ALEX_L3G4200D.h ALEX_LCD_ST7735.h ALEX_VL53L0X.h VCAN_OV7725_Eagle.h VCAN_OV7725_REG.h
  group drivers/src
    ../drivers/src/: ALEX_L3G4200D.c ALEX_LCD_ST7735.c ALEX_VL53L0X.c VCAN_OV7725_Eagle.c
  group Library/CMSIS/inc
    ../Library/CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armcc_V6.h cmsis_gcc.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group Library/MKV58F24
    ../Library/MKV58F24/: fsl_device_registers.h MKV58F24.h MKV58F24_features.h
  group Library/MKV58F24/Peripheral Drivers
    ../Library/MKV58F24/drivers/: Driver_CAN.h Driver_Common.h Driver_ETH.h Driver_ETH_MAC.h Driver_ETH_PHY.h Driver_Flash.h Driver_I2C.h Driver_MCI.h Driver_NAND.h Driver_SAI.h Driver_SPI.h Driver_USART.h Driver_USB.h Driver_USBD.h Driver_USBH.h fsl_adc16.c fsl_adc16.h fsl_clock.c fsl_clock.h fsl_cmp.c fsl_cmp.h fsl_common.c fsl_common.h fsl_crc.c fsl_crc.h fsl_dac.c fsl_dac.h fsl_dmamux.c fsl_dmamux.h fsl_dspi.c fsl_dspi.h fsl_dspi_cmsis.c fsl_dspi_cmsis.h fsl_dspi_edma.c fsl_dspi_edma.h fsl_edma.c fsl_edma.h fsl_enet.c fsl_enet.h fsl_ewm.c fsl_ewm.h fsl_flash.c fsl_flash.h fsl_flexbus.c fsl_flexbus.h fsl_flexcan.c fsl_flexcan.h fsl_flexcan_edma.c fsl_flexcan_edma.h fsl_ftm.c fsl_ftm.h fsl_gpio.c fsl_gpio.h fsl_hsadc.c fsl_hsadc.h fsl_i2c.c fsl_i2c.h fsl_i2c_cmsis.c fsl_i2c_cmsis.h fsl_i2c_edma.c fsl_i2c_edma.h fsl_llwu.c fsl_llwu.h fsl_lptmr.c fsl_lptmr.h fsl_pdb.c fsl_pdb.h fsl_pit.c fsl_pit.h fsl_pmc.c fsl_pmc.h fsl_port.h fsl_pwm.c fsl_pwm.h fsl_rcm.c fsl_rcm.h fsl_sim.c fsl_sim.h fsl_smc.c fsl_smc.h fsl_sysmpu.c fsl_sysmpu.h fsl_trng.c fsl_trng.h fsl_uart.c fsl_uart.h fsl_uart_cmsis.c fsl_uart_cmsis.h fsl_uart_edma.c fsl_uart_edma.h fsl_wdog.c fsl_wdog.h fsl_xbara.c fsl_xbara.h fsl_xbarb.c fsl_xbarb.h
  group Library/MKV58F24/startup
    ../Library/MKV58F24/startup/: startup_MKV58F24.s system_MKV58F24.c system_MKV58F24.h
  group Library/MKV58F24/utilities
    ../Library/MKV58F24/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_notifier.c fsl_notifier.h fsl_shell.c fsl_shell.h
  group middleware/dma_manager_2.1.0
    ../middleware/dma_manager_2.1.0/: fsl_dma_manager.c fsl_dma_manager.h
  group middleware/Terminal_0.01a/inc
    ../middleware/Terminal_0.01a/inc/: MW_ALEX_Terminal.h
  group middleware/Terminal_0.01a/src
    ../middleware/Terminal_0.01a/src/: MW_ALEX_Terminal.c
