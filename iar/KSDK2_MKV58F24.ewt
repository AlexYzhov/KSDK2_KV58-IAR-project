<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>C-STAT</name>
      <archiveVersion>259</archiveVersion>
      <data>
        <version>259</version>
        <cstatargs>
          <useExtraArgs>0</useExtraArgs>
          <extraArgs></extraArgs>
          <analyzeTimeoutEnabled>1</analyzeTimeoutEnabled>
          <analyzeTimeout>600</analyzeTimeout>
          <enableParallel>0</enableParallel>
          <parallelThreads>6</parallelThreads>
          <enableFalsePositives>0</enableFalsePositives>
          <messagesLimitEnabled>1</messagesLimitEnabled>
          <messagesLimit>100</messagesLimit>
        </cstatargs>
        <cstat_settings>
          <cstat_version>1.3.4</cstat_version>
          <checks_tree>
            <package>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
              </group>
            </package>
            <package>
              <group>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
              </group>
            </package>
            <package>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
              </group>
            </package>
            <package>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
            </package>
            <package>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
            </package>
            <package>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
              </group>
            </package>
          </checks_tree>
        </cstat_settings>
      </data>
    </settings>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>C-STAT</name>
      <archiveVersion>259</archiveVersion>
      <data>
        <version>259</version>
        <cstatargs>
          <useExtraArgs>0</useExtraArgs>
          <extraArgs></extraArgs>
          <analyzeTimeoutEnabled>1</analyzeTimeoutEnabled>
          <analyzeTimeout>600</analyzeTimeout>
          <enableParallel>0</enableParallel>
          <parallelThreads>6</parallelThreads>
          <enableFalsePositives>0</enableFalsePositives>
          <messagesLimitEnabled>1</messagesLimitEnabled>
          <messagesLimit>100</messagesLimit>
        </cstatargs>
        <cstat_settings>
          <cstat_version>1.3.4</cstat_version>
          <checks_tree>
            <package>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
              </group>
            </package>
            <package>
              <group>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
              </group>
            </package>
            <package>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
              </group>
            </package>
            <package>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
            </package>
            <package>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
            </package>
            <package>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
                <check/>
                <check/>
                <check/>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
              </group>
              <group>
                <check/>
              </group>
            </package>
          </checks_tree>
        </cstat_settings>
      </data>
    </settings>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>app</name>
    <group>
      <name>inc</name>
      <file>
        <name>$PROJ_DIR$\..\app\inc\PART_ASCII.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\app\inc\PART_I2C&amp;&amp;SCCB.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\app\inc\PART_UpperCOM.h</name>
      </file>
    </group>
    <group>
      <name>src</name>
      <file>
        <name>$PROJ_DIR$\..\app\src\PART_ASCII.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\app\src\PART_I2C&amp;&amp;SCCB.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\app\src\PART_UpperCOM.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\app\include.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\app\main.c</name>
    </file>
  </group>
  <group>
    <name>board</name>
    <group>
      <name>inc</name>
      <file>
        <name>$PROJ_DIR$\..\board\inc\board.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\board\inc\clock_config.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\board\inc\pin_mux.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\board\inc\RTE_Device.h</name>
      </file>
    </group>
    <group>
      <name>src</name>
      <file>
        <name>$PROJ_DIR$\..\board\src\board.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\board\src\clock_config.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\board\src\pin_mux.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\board\BOARD_Initialize.c</name>
    </file>
  </group>
  <group>
    <name>drivers</name>
    <group>
      <name>inc</name>
    </group>
    <group>
      <name>src</name>
    </group>
  </group>
  <group>
    <name>Library</name>
    <group>
      <name>CMSIS</name>
      <group>
        <name>inc</name>
        <file>
          <name>$PROJ_DIR$\..\Library\CMSIS\Include\arm_common_tables.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\CMSIS\Include\arm_const_structs.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\CMSIS\Include\arm_math.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\CMSIS\Include\cmsis_armcc.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\CMSIS\Include\cmsis_armcc_V6.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\CMSIS\Include\cmsis_gcc.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\CMSIS\Include\core_cm7.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\CMSIS\Include\core_cmFunc.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\CMSIS\Include\core_cmInstr.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\CMSIS\Include\core_cmSimd.h</name>
        </file>
      </group>
      <group>
        <name>src</name>
      </group>
    </group>
    <group>
      <name>MKV58F24</name>
      <group>
        <name>Peripheral Drivers</name>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\Driver_CAN.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\Driver_Common.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\Driver_ETH.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\Driver_ETH_MAC.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\Driver_ETH_PHY.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\Driver_Flash.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\Driver_I2C.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\Driver_MCI.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\Driver_NAND.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\Driver_SAI.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\Driver_SPI.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\Driver_USART.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\Driver_USB.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\Driver_USBD.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\Driver_USBH.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_adc16.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_adc16.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_clock.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_clock.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_cmp.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_cmp.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_common.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_common.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_crc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_crc.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_dac.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_dac.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_dmamux.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_dmamux.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_dspi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_dspi.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_dspi_cmsis.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_dspi_cmsis.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_dspi_edma.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_dspi_edma.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_edma.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_edma.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_enet.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_enet.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_ewm.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_ewm.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_flash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_flash.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_flexbus.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_flexbus.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_flexcan.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_flexcan.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_flexcan_edma.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_flexcan_edma.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_ftm.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_ftm.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_gpio.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_gpio.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_hsadc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_hsadc.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_i2c.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_i2c.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_i2c_cmsis.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_i2c_cmsis.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_i2c_edma.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_i2c_edma.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_llwu.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_llwu.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_lptmr.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_lptmr.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_pdb.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_pdb.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_pit.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_pit.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_pmc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_pmc.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_port.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_pwm.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_pwm.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_rcm.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_rcm.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_sim.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_sim.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_smc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_smc.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_sysmpu.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_sysmpu.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_trng.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_trng.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_uart.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_uart.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_uart_cmsis.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_uart_cmsis.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_uart_edma.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_uart_edma.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_wdog.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_wdog.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_xbara.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_xbara.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_xbarb.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\drivers\fsl_xbarb.h</name>
        </file>
      </group>
      <group>
        <name>startup</name>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\startup\startup_MKV58F24.s</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\startup\system_MKV58F24.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\startup\system_MKV58F24.h</name>
        </file>
      </group>
      <group>
        <name>utilities</name>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\utilities\fsl_debug_console.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\utilities\fsl_debug_console.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\utilities\fsl_notifier.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\utilities\fsl_notifier.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\utilities\fsl_shell.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Library\MKV58F24\utilities\fsl_shell.h</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\Library\MKV58F24\fsl_device_registers.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Library\MKV58F24\MKV58F24.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Library\MKV58F24\MKV58F24_features.h</name>
      </file>
    </group>
  </group>
  <group>
    <name>middleware</name>
    <group>
      <name>dma_manager_2.1.0</name>
      <file>
        <name>$PROJ_DIR$\..\middleware\dma_manager_2.1.0\fsl_dma_manager.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\middleware\dma_manager_2.1.0\fsl_dma_manager.h</name>
      </file>
    </group>
    <group>
      <name>Terminal_0.01a</name>
      <group>
        <name>inc</name>
        <file>
          <name>$PROJ_DIR$\..\middleware\Terminal_0.01a\inc\MW_ALEX_Terminal.h</name>
        </file>
      </group>
      <group>
        <name>src</name>
        <file>
          <name>$PROJ_DIR$\..\middleware\Terminal_0.01a\src\MW_ALEX_Terminal.c</name>
        </file>
      </group>
    </group>
  </group>
  <file>
    <name>$PROJ_DIR$\MKV58F1M0xxx24_flash.icf</name>
  </file>
</project>


